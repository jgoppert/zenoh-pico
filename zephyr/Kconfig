## zephyr/Kconfig
```kconfig
config ZENOHPICO
	bool "Enable ZenohPico"
	help
		Set this option to enable ZenohPico
```
